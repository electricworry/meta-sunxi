FILESEXTRAPATHS:prepend:orange-pi-zero3 := "${THISDIR}/orange-pi-zero3:"

SRC_URI:append:orange-pi-zero3 = " file://asound.conf"
